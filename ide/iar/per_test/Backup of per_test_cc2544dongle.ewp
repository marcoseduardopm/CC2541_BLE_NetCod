# IAR project Backup of per_test_cc2544dongle.ewp, settings and files
configuration srf05_cc2544 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2544F32.i51
  ICC8051.CCDefines: chip=2544; POWER_SAVING=0
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\source\components; ..\..\..\source\components\common; ..\..\..\source\components\common\cc8051; ..\..\..\source\components\targets\interface; ..\..\..\source\components\targets\cc2544_dongle; ..\..\..\source\components\devices\cc254x; ..\..\..\source\components\utils; ..\..\..\source\apps
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: chip=2544
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2544F32.xcl
  group application
    ../../../source/apps/per_test/: per_test_cc254x.c per_test_cc254x.h
  group common
    ../../../source/components/common/: hal_defs.h hal_types.h
  group common/8051
    ../../../source/components/common/cc8051/: hal_cc8051.h
  group devices/cc254x
    ../../../source/components/devices/cc254x/: clock.c clock.h hal_mcu.c hal_rf_proprietary.c hal_rf_proprietary.h hal_sleep.c hal_sleep.h hal_timer2.c hal_timer2.h ioCC254x_bitdef.h power_mode.h power_mode.s51 prop_regs.h
  group targets/cc2544_dongle
    ../../../source/components/targets/cc2544_dongle/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_int.c
  group targets/interface
    ../../../source/components/targets/interface/: hal_button.h hal_mcu.h
  group utils
    ../../../source/components/utils/: util.c util.h
