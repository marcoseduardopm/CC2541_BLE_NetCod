# IAR project BLE_NC_cc2541em.ewp, settings and files
configuration BLE_NC_cc2541em (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: chip=2541; POWER_SAVING=1; LCD_EXCLUDE
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\source\components\common; ..\..\..\source\components\common\cc8051; ..\..\..\source\components\targets\srf05_soc; ..\..\..\source\components\targets\interface; ..\..\..\source\components\devices\cc254x; ..\..\..\source\components\; ..\..\..\source\components\utils; ..\..\..\source\apps\BLE_NC
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: chip=2541
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2541F256_banked.xcl
  group application
    ../../../source/apps/BLE_NC/: BLE_NC_cc254x.c BLE_NC_cc254x.h CommonFunctions.c CommonFunctions.h DestinyFunctions.c DestinyFunctions.h NodeFunctions.c NodeFunctions.h ps_inv.c ps_inv.h
  group common
    ../../../source/components/common/: hal_defs.h hal_int.c hal_types.h
  group common/8051
    ../../../source/components/common/cc8051/: adc.c adc.h hal_cc8051.h
  group devices/cc254x
    ../../../source/components/devices/cc254x/: clock.c clock.h dma.h hal_mcu.c hal_rf_broadcast.c hal_rf_broadcast.h hal_rf_proprietary.c hal_rf_proprietary.h hal_sleep.c hal_sleep.h hal_timer2.c hal_timer2.h ioCC254x_bitdef.h power_mode.h power_mode.s51 prop_regs.h
  group targets/common
    ../../../source/components/targets/common/: hal_lcd_dummy.c hal_lcd_srf05.c
  group targets/interface
    ../../../source/components/targets/interface/: hal_button.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h
  group targets/srf05_soc
    ../../../source/components/targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_joystick.c hal_led.c hal_potmeter.c
  group utils
    ../../../source/components/utils/: util.c util.h util_lcd.c util_lcd.h
